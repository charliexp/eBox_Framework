# Keil uVision project stm32f0x.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RBHx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: STM32F072xB USE_FULL_LL_DRIVER
  c include: ..\..\..\mcuLib\stm32f0xx\libraries\CMSIS\Include;..\..\..\mcuLib\stm32f0xx\libraries\STM32F0xx_HAL_Driver\Inc;..\..\..\mcuLib\stm32f0xx\libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\ebox\hardware\cortex-m0;..\..\..\ebox\hardware\cortex-m0\core;..\..\..\ebox\hardware\cortex-m0\middle;..\..\..\ebox\hardware\cortex-m0\Peripherals;..\..\..\common\util;..\..\..\user\f0;..\..\..\mcuLib\stm32f0xx\libraries\ebox;..\..\..\ebox\core;..\..\..\ebox\core\stdFun
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group start_code
    ../../../mcuLib/stm32f0xx/libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x6.s startup_stm32f030x8.s startup_stm32f030xc.s startup_stm32f031x6.s startup_stm32f038xx.s startup_stm32f042x6.s startup_stm32f048xx.s startup_stm32f051x8.s startup_stm32f058xx.s startup_stm32f070x6.s startup_stm32f070xb.s startup_stm32f071xb.s startup_stm32f072xb.s startup_stm32f078xx.s startup_stm32f091xc.s startup_stm32f098xx.s
  group CMSIS
    ../../../mcuLib/stm32f0xx/libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group libraries_LL
    ../../../mcuLib/stm32f0xx/libraries/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_adc.c stm32f0xx_ll_comp.c stm32f0xx_ll_crc.c stm32f0xx_ll_crs.c stm32f0xx_ll_dac.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_i2c.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_rtc.c stm32f0xx_ll_spi.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
  group libraries_HAL
    ../../../mcuLib/stm32f0xx/libraries/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_msp_template.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_timebase_rtc_alarm_template.c stm32f0xx_hal_timebase_rtc_wakeup_template.c stm32f0xx_hal_timebase_tim_template.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c
  group eboxFun
    ../../../ebox/core/stdFun/: big_little.c crc.c ebox_mem.c ebox_printf.c fifo.c itoa.c math_misc.c util.c Dstring.cpp list.cpp new.cpp print.cpp random.cpp ringbuf.cpp sort.cpp WString.cpp
  group ebox_mcu
    ../../../ebox/hardware/cortex-m0/: object.cpp
  group ebox
    ../../../ebox/hardware/cortex-m0/Peripherals/: ebox_analog.cpp ebox_exti.cpp ebox_gpio.cpp ebox_i2c.cpp ebox_iflash.cpp ebox_rtc.cpp ebox_spi.cpp ebox_tim.cpp ebox_wdg.cpp ebox_uart.cpp
    ../../../ebox/hardware/cortex-m0/core/: ebox_core.cpp
    ../../../ebox/hardware/cortex-m0/: ebox.h ebox_debug.h ebox_define.h
  group user
    ../../../user/f0/: bsp_f0.cpp ebox_it.cpp main.cpp bsp.h ebox_config.h
  group util
    ../../../common/util/: printf.cpp
  group note
    ../../../ebox/hardware/cortex-m0/: note.txt
  group example
    ../../../example/1.digital/: 1.gpio_write.cpp
